# Keil uVision project Motor.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: elif1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F030
  c include: ..\User\AOs;..\User\dmc;..\User\drv;..\User\main;..\User\QP_nano;..\STM32F0xx_StdPeriph_Driver\inc;..\Device\CMSIS\Include;..\Device\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000100 size 0x1f00
  group main
    ../User/main/: bsp.c main.c system_core.c protect.c system_module.c stm32f0xx_it.c
  group drv
    ../User/drv/: Output.c ADC.c Input.c I2C_BQ769xx.c USART_MODBUS.c flash_EEPROM.c
  group dmc
    ../User/dmc/: delay.c LED_flicker.c CRC8.c CRC16.c
  group AOs
    ../User/AOs/: AO_EEPROM.c AO_BMS.c AO_SH36730x0.c
  group QP_nano
    ../User/QP_nano/: qepn.c qfn.c
  group StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ../Device/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group MDK-ARM
    ../Device/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
